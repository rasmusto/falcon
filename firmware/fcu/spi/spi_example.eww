<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\spi_interrupt_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\spi_polled_example.ewp</path>
  </project>
  <batchBuild/>
</workspace>


